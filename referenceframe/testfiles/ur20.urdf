Commit message: same orientation as what is used in prod right now

File: referenceframe/testfiles/ur20.urdf (robot description, URDF)
Before this commit: robot ur20, 10 links, 9 joints
Joints:
- joint base_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 3.141592653589793
